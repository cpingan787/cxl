# IAR project cm4.ewp, settings and files
configuration rev_d (ARM, debug)
  General.OGChipSelectEditMenu: CYT2B7_M4 Infineon CYT2B7_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: tviibe1m; CYT2B75CAS; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_d
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\drivers\adc; ..\..\..\..\..\common\src\drivers\flash; ..\..\..\..\..\common\src\drivers\ipc; ..\..\..\..\..\common\src\drivers\gpio; ..\..\..\..\..\common\src\drivers\sysint; ..\..\..\..\..\common\src\drivers\syspm; ..\..\..\..\..\common\src\mw; ..\..\..\..\..\common\src\mw\flash; ..\..\..\..\..\common\src\rtos\include; ..\..\..\..\..\common\src\rtos\portable\IAR\ARM_CM4F; ..\..\..\..\hdr\rev_d; ..\..\..\..\hdr\rev_d\ip; ..\..\..\..\hdr\rev_d\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_d; ..\..\..\..\src\drivers; ..\..\..\..\src\drivers\canfd; ..\..\..\..\src\drivers\sysclk; ..\..\..\..\src\system\rev_d; ..\..\..\..\source; ..\..\..\..\source\basic_sdk\include; ..\..\..\..\source\basic_sdk\source; ..\..\..\..\source\app\can_cycle_send; ..\..\..\..\source\app\diagnostic; ..\..\..\..\source\app\ecall; ..\..\..\..\source\app\gate_way; ..\..\..\..\source\app\mcu_cpu_sync; ..\..\..\..\source\app\parameter_store; ..\..\..\..\source\app\power_manage; ..\..\..\..\source\app\remote_control; ..\..\..\..\source\app\remote_diagnostic; ..\..\..\..\source\app\project_configure; ..\..\..\..\source\common; ..\..\..\..\source\app\vehicle_data_to_cpu; ..\..\..\..\source\app\vehicle_signal; ..\..\..\..\source\driver; ..\..\..\..\source\commonLib\include; ..\..\..\..\source\commonLib\source; ..\..\..\..\source\hal\include; ..\..\..\..\source\hal\source; ..\..\..\..\source\sdk\include; ..\..\..\..\source\sdk\source; ..\..\..\..\source\app\ecall
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\common\src\rtos\include; ..\..\..\..\source\commonLib\include
  OBJCOPY.OOCOutputFile: APP_CM4.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe_rev_d.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\src\drivers\crypto\libs\libcrypto_client_cm4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group hdr
    ../../../../../common/hdr/: cy_project.h
  group hdr/cmsis/include
    ../../../../../common/hdr/cmsis/include/: cmsis_compiler.h core_cm0plus.h
  group hdr/rev_b
    ../../../../hdr/rev_b/: bb_bsp_tviibe1m.h bb_bsp_tviibe1m_reva.h bb_bsp_tviibe1m_revc.h cy_device_headers.h cyt2b7_config.h
  group hdr/rev_b/ip
    ../../../../hdr/rev_b/ip/: cyip_backup_v2.h cyip_canfd.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
  group hdr/rev_c
    ../../../../hdr/rev_c/: bb_bsp_tviibe1m.h bb_bsp_tviibe1m_reva.h bb_bsp_tviibe1m_revc.h cy_device_headers.h cyt2b7_config.h
  group hdr/rev_c/ip
    ../../../../hdr/rev_c/ip/: cyip_backup_v2.h cyip_canfd.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
  group hdr/rev_d
    ../../../../hdr/rev_d/: bb_bsp_tviibe1m.h bb_bsp_tviibe1m_reva.h bb_bsp_tviibe1m_revc.h bb_bsp_tviibe1m_starter_kit.h cy_device_headers.h cyt2b7_config.h
  group hdr/rev_d/ip
    ../../../../hdr/rev_d/ip/: cyip_backup_v2.h cyip_canfd.h cyip_coredefines.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
  group hdr/rtos
    ../../../../../common/src/rtos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group source
    ../../../../source/: sdkdemo.c sdkdemo.h taskManage.c taskManage.h
  group source/app/can_cycle_send
    ../../../../source/app/can_cycle_send/: canPeriodTask.c canPeriodTask.h
  group source/app/diagnostic
    ../../../../source/app/diagnostic/: taskDiagnostic.c taskDiagnostic.h taskDtcProcess.c taskDtcProcess.h udsDidFunction.c udsDidFunction.h udsEolTest.c udsEolTest.h udsSecurityCalculate.c udsSecurityCalculate.h
  group source/app/ecall
    ../../../../source/app/ecall/: taskEcallProcess.c
  group source/app/mcu_cpu_sync
    ../../../../source/app/mcu_cpu_sync/: mcuMpuSyncTask.c mcuMpuSyncTask.h
  group source/app/paremeter_store
    ../../../../source/app/parameter_store/: ParameterStoreManageApp.c ParameterStoreManageApp.h
  group source/app/power_manage
    ../../../../source/app/power_manage/: taskPowerManage.c taskPowerManage.h
  group source/app/project_configure
    ../../../../source/app/project_configure/: projectConfigure.c projectConfigure.h version.c
  group source/app/remote_control
    ../../../../source/: remoteControl.c remoteControl.h
  group source/app/remote_diagnostic
    ../../../../source/app/remote_diagnostic/: remoteDiagnosticTask.c remoteDiagnosticTask.h
  group source/app/security
    ../../../../source/app/security_test/: se_hardware_hal.c
  group source/app/security/include
    ../../../../source/app/security_test/include/: se_hardware_hal.h
  group source/app/vehicle_data_to_cpu
    ../../../../source/app/vehicle_data_to_cpu/: canMsgDynamicConfigure.c canMsgDynamicConfigure.h canMsgToCpu.c canMsgToCpu.h ecuNodeMissingCheck.c ecuNodeMissingCheck.h taskVehicleDataToCpu.c taskVehicleDataToCpu.h
  group source/app/vehicle_signal
    ../../../../source/app/vehicle_signal/: vehicleSignalApp.c
  group source/commonLib/include
    ../../../../source/commonLib/include/: aes128.h crc8_16_32.h SEGGER_RTT.h SEGGER_RTT_Conf.h
  group source/commonLib/source
    ../../../../source/commonLib/source/: aes128.c crc8_16_32.c SEGGER_RTT1.c SEGGER_RTT_ASM_ARMv7M1.S SEGGER_RTT_printf1.c
  group source/hal/include
    ../../../../source/hal/include/: batteryHal.h bleHal.h canHal.h flashHal.h gSensorHal.h hsmHal.h logHal.h mpuHal.h peripheralHal.h powerManageHal.h securityHal.h timerHal.h
  group source/hal/source
    ../../../../source/hal/source/: batteryHal.c bleHal.c canHal.c ecallHal.c flashHal.c gSensorHal.c hsmHal.c logHal.c mpuHal.c peripheralHal.c powerManageHal.c securityHal.c timerHal.c
  group source/sdk/include
    ../../../../source/sdk/include/: autoSarNmSdk.h batterySdk.h canTpSdk.h firmwareUpdateSdk.h mpuPowerSyncSdk.h parameterSyncSdk.h powerManageSdk.h RemoteDiagnosticSdk.h RemoteDiagnosticUartSdk.h stateSyncSdk.h timeSyncSdk.h udsTp.h
  group source/sdk/source
    ../../../../source/sdk/source/: autosarNmSdk.c batterySdk.c canParseSdk.c canTpSdk.c firmwareUpdateSdk.c mpuPowerSyncSdk.c parameterSyncSdk.c powerManageSdk.c RemoteDiagnosticSdk.c RemoteDiagnosticUartSdk.c securitySdk.c stateSyncSdk.c timeSyncSdk.c udsTp.c
  group src
    ../../../../src/: main_cm4.c
  group src/drivers/adc
    ../../../../../common/src/drivers/adc/: cy_adc.c cy_adc.h
  group src/drivers/canfd
    ../../../../../common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group src/drivers/cpu
    ../../../../src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group src/drivers/crypto
    ../../../../../common/src/drivers/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group src/drivers/dma
    ../../../../../common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group src/drivers/evtgen
    ../../../../../common/src/drivers/evtgen/: cy_evtgen.c cy_evtgen.h
  group src/drivers/flash
    ../../../../../common/src/drivers/flash/: cy_flash.c
    ../../../../src/drivers/flash/: cy_flash.h
  group src/drivers/gpio
    ../../../../../common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group src/drivers/ipc
    ../../../../../common/src/drivers/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group src/drivers/lin
    ../../../../../common/src/drivers/lin/: cy_lin.c cy_lin.h
  group src/drivers/lvd
    ../../../../../common/src/drivers/lvd/: cy_lvd.c cy_lvd.h
  group src/drivers/mcwdt
    ../../../../../common/src/drivers/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group src/drivers/mpu
    ../../../../../common/src/drivers/mpu/: cy_mpu.c cy_mpu.h
  group src/drivers/prot
    ../../../../../common/src/drivers/prot/: cy_prot.c cy_prot.h
  group src/drivers/scb
    ../../../../../common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group src/drivers/smartio
    ../../../../../common/src/drivers/smartio/: cy_smartio.c cy_smartio.h
  group src/drivers/srom
    ../../../../../common/src/drivers/srom/: cy_srom.c cy_srom.h
  group src/drivers/sysclk
    ../../../../src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group src/drivers/sysflt
    ../../../../../common/src/drivers/sysflt/: cy_sysflt.c cy_sysflt.h
    ../../../../src/drivers/sysflt/: cy_sysflt_config.h
  group src/drivers/sysint
    ../../../../../common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group src/drivers/syslib
    ../../../../../common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
    ../../../../../common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group src/drivers/syspm
    ../../../../../common/src/drivers/syspm/: cy_syspm.c cy_syspm.h
  group src/drivers/sysreset
    ../../../../../common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group src/drivers/sysrtc
    ../../../../../common/src/drivers/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group src/drivers/systick
    ../../../../../common/src/drivers/systick/: cy_systick.c cy_systick.h
  group src/drivers/syswdt
    ../../../../../common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group src/drivers/tcpwm
    ../../../../../common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group src/drivers/trigmux
    ../../../../../common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
  group src/interrupts/rev_b
    ../../../../src/interrupts/rev_b/: cy_interrupt_map.c cy_interrupt_map_cm4.h
  group src/interrupts/rev_c
    ../../../../src/interrupts/rev_c/: cy_interrupt_map.c cy_interrupt_map_cm4.h
  group src/interrupts/rev_d
    ../../../../src/interrupts/rev_d/: cy_interrupt_map.c cy_interrupt_map_cm4.h
  group src/mw/button
    ../../../../../common/src/mw/button/: cy_button.c cy_button.h
  group src/mw/flash
    ../../../../../common/src/mw/flash/: cy_mw_flash.c cy_mw_flash.h
  group src/mw/semihosting
    ../../../../../common/src/mw/semihosting/: cy_semihosting.c cy_semihosting.h
  group src/mw/sw_timer
    ../../../../../common/src/mw/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group src/rtos
    ../../../../../common/src/rtos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group src/rtos/mem_mgmt
    ../../../../../common/src/rtos/portable/MemMang/: heap_4.c
  group src/rtos/portable
    ../../../../../common/src/rtos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group src/startup
    ../../../../../common/src/startup/: startup.c startup_customize.h
    ../../../../../common/src/startup/iar/: startup_cm4.s
  group src/system/rev_b
    ../../../../src/system/rev_b/: system_cyt2b7.h system_tviibe1m_cm4.c
  group src/system/rev_c
    ../../../../src/system/rev_c/: system_cyt2b7.h system_tviibe1m_cm4.c
  group src/system/rev_d
    ../../../../src/system/rev_d/: system_cyt2b7.h system_tviibe1m_cm4.c
